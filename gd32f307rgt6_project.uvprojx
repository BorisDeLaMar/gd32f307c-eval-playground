# Keil uVision project gd32f307rgt6_project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: GD32F307RG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32f307rgt6_project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=8 wLevel=4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group src
    ./: main.c cfg.c my_tasks.c irqs.c utils.c
  group inc
    ./: main.h cfg.h my_tasks.h irqs.h defines.h structs.h utils.h
software components: RTOS:Config 11.3.0, RTOS:Core 11.3.0, RTOS:Coroutines 11.3.0, RTOS:Event Groups 11.3.0, RTOS:Heap 11.3.0, RTOS:Timers 11.3.0, CMSIS:CORE 5.6.0, Device:EVAL:GD32F307 2.2.0, Device:GD32F30x_StdPeripherals:DMA 2.2.0, Device:GD32F30x_StdPeripherals:EXTI 2.2.0, Device:GD32F30x_StdPeripherals:GPIO 2.2.0, Device:GD32F30x_StdPeripherals:I2C 2.2.0, Device:GD32F30x_StdPeripherals:MISC 2.2.0, Device:GD32F30x_StdPeripherals:PMU 2.2.0, Device:GD32F30x_StdPeripherals:RCU 2.2.0, Device:GD32F30x_StdPeripherals:SPI_I2S 2.2.0, Device:GD32F30x_StdPeripherals:TIMER 2.2.0, Device:GD32F30x_StdPeripherals:USART 2.1.0, Device:GD32F30x_libopt 2.2.0, Device:Startup 2.2.0
